Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Flow-Lounge armchair - ver4.ifc
Time: 2025-11-11T17:44:13
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (7)
Name
 | Flow-Lounge armchair_0 - ObjectType: SketchupGroup
 | Flow-Lounge armchair_1 - ObjectType: SketchupGroup
 | Flow-Lounge armchair_2 - ObjectType: SketchupGroup
 | Flow-Lounge armchair_3 - ObjectType: SketchupGroup
 | Flow-Lounge armchair_4 - ObjectType: SketchupGroup
 | Flow-Lounge armchair_5 - ObjectType: SketchupGroup
 | Flow-Lounge armchair_6 - ObjectType: SketchupGroup
